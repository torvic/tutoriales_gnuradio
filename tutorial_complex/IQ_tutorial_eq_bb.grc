options:
  parameters:
    author: C. Seguinot
    category: Custom
    copyright: GNU GPL V3
    description: 'IQ tutorial : Illustration of equivalent baseband signal'
    generate_options: qt_gui
    id: IQ_tutorial_eq_bb
    output_language: python
    title: equivalent baseband signal
  states: {}

blocks:
- name: delta_f
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Delta F (Hz)
    start: '-1.5*samp_rate'
    step: 1/12
    stop: 1.5*samp_rate
    value: '0'
  states: {}
- name: phi
  id: variable
  parameters:
    comment: Choose -180<phi<+180
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    comment: rotation per minute
    const: delta_f*60
    type: float
  states: {}
- name: analog_sig_source_x_1_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Carrier
    freq: delta_f
    offset: '0'
    phase: phi
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 1,0,1,1
    size: '256'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1,1,1
    label1: Input signal
    type: complex
    ymax: '0'
    ymin: '-60'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    comment: |-
      Used to display rotation speed 
      in Rpm (rotation per min)
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 0,1,1,1
    max: '100'
    min: '-100'
    name: Rpm=delta_f*60
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,2,2
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '0.1'
  states: {}

connections:
- [analog_const_source_x_0, '0', qtgui_number_sink_0, '0']
- [analog_sig_source_x_1_1, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
