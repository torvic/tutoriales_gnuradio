options:
  parameters:
    generate_options: qt_gui
    id: chat_app
    output_language: python
    title: chat
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: Input
    type: string
    value: Send
  states: {}
- name: zeromq_pull_msg_source_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:50261
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:50261
    timeout: '100'
  states: {}

connections:
- [qtgui_edit_box_msg_0_0, msg, zeromq_push_msg_sink_0_0, in]
- [zeromq_pull_msg_source_0_0, out, blocks_message_debug_0_0, print]

metadata:
  file_format: 1
