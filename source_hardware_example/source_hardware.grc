options:
  parameters:
    generate_options: qt_gui
    id: source_hardware
    output_language: python
    title: source hardware example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '50'
    samp_rate: samp_rate
    type: fcc
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [audio_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
